# IAR project USBD_AUDIO.ewp, settings and files
configuration STM32F446E-EVAL_UAC10-PLAY (ARM, debug)
  General.OGChipSelectEditMenu: STM32F446ZE ST STM32F446ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F446xx; USE_STM32446E_EVAL; USE_USB_FS; USE_USB_AUDIO_PLAYBACK=1
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\common; ..\..\..\..\..\..\Drivers\BSP\STM32446E_EVAL; ..\..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\PDM; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\Common\Middlewares\ST\STM32_USB_Device_Library\Class\AUDIO_10\Inc; ..\..\..\..\..\Common\Streaming\Inc; ..\..\Extension\Drivers\BSP\STM32446E_EVAL; ..\..\Extension\Drivers\BSP\Components\wm8994; ..\..\Extension\Drivers\STM32F4xx_HAL_Driver
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_MSC.bin
  ILINK.IlinkOutputFile: STM32446E-EVAL_USBD-FS.out
  ILINK.IlinkIcfFile: stm32f446_flash_Playback.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F446E-EVAL_UAC10-DUM (ARM, debug)
  as the first configuration, except:
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F446xx; USE_STM32446E_EVAL; USE_USB_FS; USE_USB_AUDIO_RECORDING=1; USE_AUDIO_DUMMY_MIC=1
  ICCARM.CCOptStrategy: 2
  ILINK.IlinkIcfFile: stm32f446_flash_Recording.icf
configuration STM32F446E-EVAL_UAC10-ADV (ARM, debug)
  as the first configuration, except:
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F446xx; USE_STM32446E_EVAL; USE_USB_FS; USE_HAL_DRIVER; STM32F446xx; USE_STM32446E_EVAL; USE_USB_FS; USE_USB_AUDIO_PLAYBACK=1; USE_USB_AUDIO_RECORDING=1; USE_AUDIO_MEMS_MIC=1
  ILINK.IlinkIcfFile: stm32f446_flash_Advanced.icf
configuration STM32F446E-EVAL_UAC10-REC (ARM, debug)
  as the first configuration, except:
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F446xx; USE_STM32446E_EVAL; USE_USB_FS; USE_USB_AUDIO_RECORDING=1; USE_AUDIO_MEMS_MIC=1
  ILINK.IlinkIcfFile: stm32f446_flash_Recording.icf
  group Application/Common/Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO_10
    ../../../../../Common/Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO_10/Src/: usbd_audio.c
  group Application/Common/Middlewares/ST/STM32_USB_Device_Library/Core
    ../../../../../Common/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core_ex.c
  group Application/Common/Streaming
    ../../../../../Common/Streaming/Src/: audio_dummymic_node.c audio_dummyspeaker_node.c audio_usb_nodes.c audio_usb_playback_session.c audio_usb_recording_session.c usbd_audio_10_config_descriptors.c usbd_audio_if.c
  group Application/EWARM
    ./: startup_stm32f446xx.s
  group Application/Extension/Drivers/BSP/Components
    ../../Extension/Drivers/BSP/Components/wm8994/: wm8994_ex.c
  group Application/Extension/Drivers/BSP/STM32446E_EVAL
    ../../Extension/Drivers/BSP/STM32446E_EVAL/: stm32446e_eval_audio_ex.c
  group Application/User
    ../Src/: audio_mic_node.c audio_speaker_node.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c usbd_conf.c usbd_desc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32446E_EVAL
    ../../../../../../Drivers/BSP/STM32446E_EVAL/: stm32446e_eval.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_usb.c
  group Middlewares/PDM
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_IAR_wc32.a
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c
