# Keil uVision project Project.uvprojx, settings and files
target STM32F446E-EVAL_UAC10-PLAY (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F446ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F446E-EVAL_UAC10-PLAY
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx,USE_STM32446E_EVAL,USE_USB_FS,USE_USB_AUDIO_PLAYBACK=1
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/Components/common;../../../../../../Drivers/BSP/STM32446E_EVAL;../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../Common/Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO_10/Inc;../../../../../Common/Streaming/Inc;../../Extension/Drivers/BSP/STM32446E_EVAL;../../Extension/Drivers/BSP/Components/wm8994;../../Extension/Drivers/STM32F4xx_HAL_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/Common/Middlewares/ST/STM32_USB_Device_Library/Core
    ../../../../../Common/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core_ex.c
  group Application/Extension/Drivers/BSP/Components
    ../../Extension/Drivers/BSP/Components/wm8994/: wm8994_ex.c
  group Application/User
    ../Src/: main.c usbd_conf.c stm32f4xx_it.c audio_mic_node.c usbd_desc.c audio_speaker_node.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash.c stm32f4xx_hal_sram.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_sai.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_tim.c stm32f4xx_hal_i2c.c stm32f4xx_ll_usb.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_rcc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/Common/Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO_10
    ../../../../../Common/Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO_10/Src/: usbd_audio.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c
  group Drivers/BSP/STM32446E_EVAL
    ../../../../../../Drivers/BSP/STM32446E_EVAL/: stm32446e_eval.c
  group Application/MDK-ARM
    ./: startup_stm32f446xx.s
  group Application/Common/Streaming
    ../../../../../Common/Streaming/Src/: audio_usb_recording_session.c audio_dummymic_node.c usbd_audio_if.c usbd_audio_10_config_descriptors.c audio_dummyspeaker_node.c audio_usb_nodes.c audio_usb_playback_session.c
  group Middlewares/PDM
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_Keil_wc16.lib
  group Application/Extension/Drivers/BSP/STM32446E_EVAL
    ../../Extension/Drivers/BSP/STM32446E_EVAL/: stm32446e_eval_audio_ex.c
  group Doc
    ../: readme.txt
target STM32F446E-EVAL_UAC10-DUM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F446ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: STM32F446E-EVAL_UAC10-DUM
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx,USE_STM32446E_EVAL,USE_USB_FS,USE_USB_AUDIO_RECORDING=1,USE_AUDIO_DUMMY_MIC=1
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target STM32F446E-EVAL_UAC10-ADV (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F446ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: STM32F446E-EVAL_UAC10-ADV
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx,USE_STM32446E_EVAL,USE_USB_FS,USE_HAL_DRIVER,STM32F446xx,USE_STM32446E_EVAL,USE_USB_FS,USE_USB_AUDIO_PLAYBACK=1,USE_USB_AUDIO_RECORDING=1,USE_AUDIO_MEMS_MIC=1
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target STM32F446E-EVAL_UAC10-REC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F446ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: STM32F446E-EVAL_UAC10-REC
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx,USE_STM32446E_EVAL,USE_USB_FS,USE_USB_AUDIO_RECORDING=1,USE_AUDIO_MEMS_MIC=1
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 4.3.0
