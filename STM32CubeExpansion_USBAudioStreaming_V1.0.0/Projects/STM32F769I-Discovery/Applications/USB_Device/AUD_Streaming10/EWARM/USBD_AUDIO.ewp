# IAR project USBD_AUDIO.ewp, settings and files
configuration STM32F769I-DISCO_UAC10-PLAY (ARM, debug)
  General.OGChipSelectEditMenu: STM32F769NI ST STM32F769NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F769xx; USE_STM32F769I_DISCO; USE_IOEXPANDER; USE_USB_FS; USE_USB_FS_INTO_HS; USE_USB_AUDIO_PLAYBACK=1
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32F769I-Discovery; ..\..\..\..\..\..\Drivers\BSP\Components\common; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\..\Common\Middlewares\ST\STM32_USB_Device_Library\Class\AUDIO_10\Inc; ..\..\..\..\..\Common\Streaming\Inc; ..\..\Extension\Drivers\BSP\STM32F769I-Discovery; ..\..\Extension\Drivers\BSP\Components\wm8994; ..\..\Extension\Drivers\STM32F7xx_HAL_Driver
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F769I-DISCOVERY_USBD-FS.hex
  ILINK.IlinkOutputFile: STM32F769I-DISCOVERY_USBD-FS.out
  ILINK.IlinkIcfFile: stm32f769xx_playback.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F769I-DISCO_UAC10-REC (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F769xx; USE_STM32F769I_DISCO; USE_IOEXPANDER; USE_USB_FS; USE_USB_FS_INTO_HS; USE_USB_AUDIO_RECORDING=1; USE_AUDIO_DFSDM_MEMS_MIC=1
  ILINK.IlinkIcfFile: stm32f769xx_recording.icf
configuration STM32F769I-DISCO_UAC10-DUM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F769xx; USE_STM32F769I_DISCO; USE_IOEXPANDER; USE_USB_FS; USE_USB_FS_INTO_HS; USE_USB_AUDIO_CLASS_10; USE_USB_AUDIO_RECORDING; USE_AUDIO_DUMMY_MIC; NUSE_AUDIO_RECORDING_USB_IMPLECIT_SYNCHRO; USE_AUDIO_RECORDING_24_BIT; USE_AUDIO_USB_RECORD_MULTI_FREQUENCES
  ILINK.IlinkIcfFile: stm32f769xx_recording.icf
configuration STM32F769I-DISCO_UAC10-ADV (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F769xx; USE_STM32F769I_DISCO; USE_IOEXPANDER; USE_USB_FS; USE_USB_FS_INTO_HS; USE_USB_AUDIO_PLAYBACK=1; USE_USB_AUDIO_RECORDING=1; USE_AUDIO_DFSDM_MEMS_MIC=1
  ILINK.IlinkIcfFile: stm32f769xx_adv.icf
  group Application/Common/Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO_10
    ../../../../../Common/Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO_10/Src/: usbd_audio.c
  group Application/Common/Middlewares/ST/STM32_USB_Device_Library/Core
    ../../../../../Common/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core_ex.c
  group Application/Common/Streaming
    ../../../../../Common/Streaming/Src/: audio_dummymic_node.c audio_dummyspeaker_node.c audio_usb_nodes.c audio_usb_playback_session.c audio_usb_recording_session.c usbd_audio_10_config_descriptors.c usbd_audio_if.c
  group Application/EWARM
    ./: startup_stm32f769xx.s
  group Application/Extension/Drivers/BSP/Components/wm8994
    ../../Extension/Drivers/BSP/Components/wm8994/: wm8994_ex.c
  group Application/Extension/Drivers/BSP/STM32F769I-DISCOVERY
    ../../Extension/Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery_audio_ex.c
  group Application/User
    ../Src/: audio_mic_node.c audio_speaker_node.c main.c stm32f7xx_hal_msp.c stm32f7xx_it.c usbd_conf.c usbd_desc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32F769I-Discovery
    ../../../../../../Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2s.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_ll_usb.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c
