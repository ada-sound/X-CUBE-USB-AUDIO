# Keil uVision project Project.uvprojx, settings and files
target STM32F769I-DISCO_UAC10-PLAY (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: STMicroelectronics.STM32F7xx_DFP.1.0.3
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F769I-DISCO_UAC10-PLAY
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_DISCO,USE_IOEXPANDER,USE_USB_FS,USE_USB_FS_INTO_HS,USE_USB_AUDIO_PLAYBACK=1
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/STM32F7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32F769I-Discovery;../../../../../../Drivers/BSP/Components/common;../../../../../../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../Common/Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO_10/Inc;../../../../../Common/Streaming/Inc;../../Extension/Drivers/BSP/STM32F769I-Discovery;../../Extension/Drivers/BSP/Components/wm8994;../../Extension/Drivers/STM32F7xx_HAL_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_i2s.c stm32f7xx_hal_uart.c stm32f7xx_hal.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_ll_usb.c stm32f7xx_hal_i2c.c stm32f7xx_hal_usart.c stm32f7xx_hal_cortex.c stm32f7xx_hal_flash.c stm32f7xx_hal_pcd.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c
  group Application/Extension/Drivers/BSP/Components/wm8994
    ../../Extension/Drivers/BSP/Components/wm8994/: wm8994_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Application/MDK-ARM
    ./: startup_stm32f769xx.s
  group Application/Extension/Drivers/BSP/STM32F769I-DISCOVERY
    ../../Extension/Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery_audio_ex.c
  group Application/Common/Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO_10
    ../../../../../Common/Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO_10/Src/: usbd_audio.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c
  group Application/User
    ../Src/: stm32f7xx_hal_msp.c usbd_conf.c stm32f7xx_it.c audio_mic_node.c usbd_desc.c main.c audio_speaker_node.c
  group Doc
    ../: readme.txt
  group Application/Common/Streaming
    ../../../../../Common/Streaming/Src/: usbd_audio_if.c usbd_audio_10_config_descriptors.c audio_dummyspeaker_node.c audio_dummymic_node.c audio_usb_nodes.c audio_usb_recording_session.c audio_usb_playback_session.c
  group Drivers/BSP/STM32F769I-Discovery
    ../../../../../../Drivers/BSP/STM32F769I-Discovery/: stm32f769i_discovery.c
  group Application/Common/Middlewares/ST/STM32_USB_Device_Library/Core
    ../../../../../Common/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core_ex.c
target STM32F769I-DISCO_UAC10-REC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: STMicroelectronics.STM32F7xx_DFP.1.0.3
  cpu: as above
  output: STM32F769I-DISCO_UAC10-REC
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_DISCO,USE_IOEXPANDER,USE_USB_FS,USE_USB_FS_INTO_HS,USE_USB_AUDIO_RECORDING=1,USE_AUDIO_DFSDM_MEMS_MIC=1
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
target STM32F769I-DISCO_UAC10-DUM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: STMicroelectronics.STM32F7xx_DFP.1.0.3
  cpu: as above
  output: STM32F769I-DISCO_UAC10-DUM
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_DISCO,USE_IOEXPANDER,USE_USB_FS,USE_USB_FS_INTO_HS,USE_USB_AUDIO_CLASS_10,USE_USB_AUDIO_RECORDING,USE_AUDIO_DUMMY_MIC,NUSE_AUDIO_RECORDING_USB_IMPLECIT_SYNCHRO,USE_AUDIO_RECORDING_24_BIT,USE_AUDIO_USB_RECORD_MULTI_FREQUENCES
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
target STM32F769I-DISCO_UAC10-ADV (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: STMicroelectronics.STM32F7xx_DFP.1.0.3
  cpu: as above
  output: STM32F769I-DISCO_UAC10-ADV
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F769xx,USE_STM32F769I_DISCO,USE_IOEXPANDER,USE_USB_FS,USE_USB_FS_INTO_HS,USE_USB_AUDIO_PLAYBACK=1,USE_USB_AUDIO_RECORDING=1,USE_AUDIO_DFSDM_MEMS_MIC=1
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
software components: CMSIS:CORE 4.3.0
